options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_digital_gain_network_host
    output_language: python
  states: {}

blocks:
- name: ampl_i
  id: variable_qtgui_range
  parameters:
    label: Constant I
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '1.0'
  states: {}
- name: ampl_q
  id: variable_qtgui_range
  parameters:
    label: Constant Q
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '1'
  states: {}
- name: enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Enable
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Sine Freq
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: samp_rate/10
  states: {}
- name: gain_digital
  id: variable_qtgui_range
  parameters:
    label: Gain (Digital)
    orient: Qt.Horizontal
    start: '0.0'
    step: '1'
    stop: '100.0'
    value: '1.0'
  states: {}
- name: gain_siggen
  id: variable_qtgui_range
  parameters:
    label: Gain (Siggen)
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '1.0'
  states: {}
- name: ip_addr
  id: variable
  parameters:
    value: '"192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    label: Waveform
    label0: Constant
    label1: Sine Wave
    label2: Noise
    num_opts: '3'
    option1: SINE_WAVE
    option2: NOISE
    type: string
    value: SINE_WAVE
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '1234'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: xmlrpc_client_freq
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_enable
    port: '8080'
    variable: enable
  states: {}
- name: xmlrpc_client_freq_0
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_ampl_i
    port: '8080'
    variable: ampl_i
  states: {}
- name: xmlrpc_client_freq_1
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_ampl_q
    port: '8080'
    variable: ampl_q
  states: {}
- name: xmlrpc_client_freq_2
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_freq
    port: '8080'
    variable: freq
  states: {}
- name: xmlrpc_client_freq_2_0
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_gain_siggen
    port: '8080'
    variable: gain_siggen
  states: {}
- name: xmlrpc_client_freq_2_0_0
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_gain_digital
    port: '8080'
    variable: gain_digital
  states: {}
- name: xmlrpc_client_freq_3
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_waveform
    port: '8080'
    variable: waveform
  states: {}

connections:
- [blocks_udp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_udp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
