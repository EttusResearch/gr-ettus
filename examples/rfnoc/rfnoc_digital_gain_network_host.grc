<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_digital_gain_network_host</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ampl_i</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>label</key><value>Constant I</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ampl_q</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Constant Q</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>enable</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>Enable</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>samp_rate/10</value></param>
<param><key>label</key><value>Sine Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>step</key><value>samp_rate/100</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_digital</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>label</key><value>Gain (Digital)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_siggen</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>label</key><value>Gain (Siggen)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_addr</value></param>
<param><key>value</key><value>"192.168.10.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>waveform</value></param>
<param><key>value</key><value>SINE_WAVE</value></param>
<param><key>label0</key><value>Constant</value></param>
<param><key>label1</key><value>Sine Wave</value></param>
<param><key>label2</key><value>Noise</value></param>
<param><key>label</key><value>Waveform</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>CONSTANT</value></param>
<param><key>option1</key><value>SINE_WAVE</value></param>
<param><key>option2</key><value>NOISE</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_freq</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_enable</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>enable</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_freq_0</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_ampl_i</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>ampl_i</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_freq_1</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_ampl_q</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>ampl_q</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_freq_2</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_freq</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>freq</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_freq_2_0</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_gain_siggen</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>gain_siggen</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_freq_2_0_0</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_gain_digital</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>gain_digital</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_freq_3</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_waveform</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>waveform</value></param>
</block>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
