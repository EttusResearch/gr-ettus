options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_vector_iir
    output_language: python
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.984375'
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.015625'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: num_points
  id: variable
  parameters:
    value: '256'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: RX Frequency
    orient: Qt.Horizontal
    start: 50e6
    step: 10e6
    stop: 6e9
    value: 2440e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: variable_ettus_device3_0
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: ''
  states: {}
- name: wave_amp
  id: variable_qtgui_range
  parameters:
    label: Wave Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.9'
  states: {}
- name: wave_freq
  id: variable_qtgui_range
  parameters:
    label: Wave Freq
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/128
    stop: samp_rate/2
    value: samp_rate/8
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: wave_amp
    freq: wave_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: num_points
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters:
    vlen: num_points
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: num_points
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: num_points
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_points
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_points
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_points
    type: complex
  states: {}
- name: ettus_rfnoc_split_stream_0
  id: ettus_rfnoc_split_stream
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_split_stream
    grvlen: num_points
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_ddc_0
  id: ettus_rfnoc_streamer_ddc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_ddc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: num_points
    input_rate: 200e6
    num_chans: '1'
    output_rate: samp_rate
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fft_0
  id: ettus_rfnoc_streamer_fft
  parameters:
    block_index: '-1'
    device_index: '-1'
    direction: '"forward"'
    fft_size: num_points
    fpga_module_name: noc_block_fft
    magnitude_out: '"MAGNITUDE_SQUARED"'
    scaling: '1706'
    shift: '"normal"'
  states: {}
- name: ettus_rfnoc_streamer_fifo_0_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: num_points
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: ''
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: rx_freq
    freq1: 1.982e9
    gain0: rx_gain
    gain1: '20'
    grvlen: num_points
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: 200e6
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: spp=256
  states: {state: disabled}
- name: ettus_rfnoc_streamer_vector_iir_0
  id: ettus_rfnoc_streamer_vector_iir
  parameters:
    alpha: alpha
    beta: beta
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_vector_iir
    vlen: num_points
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: beta
    fftaps: alpha
    type: ccf
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    label1: Reference
    label2: FPGA
    nconnections: '2'
    showports: 'True'
    vlen: num_points
    x_start: '-samp_rate/2'
    x_step: samp_rate/num_points
    x_units: '"dB"'
    y_units: '"MHz"'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_real_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', ettus_rfnoc_streamer_fifo_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', iir_filter_xxx_0, '0']
- [ettus_rfnoc_split_stream_0, '0', blocks_vector_to_stream_0, '0']
- [ettus_rfnoc_split_stream_0, '1', ettus_rfnoc_streamer_vector_iir_0, '0']
- [ettus_rfnoc_streamer_ddc_0, '0', ettus_rfnoc_streamer_fft_0, '0']
- [ettus_rfnoc_streamer_fft_0, '0', virtual_sink_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0, '0', ettus_rfnoc_streamer_fft_0, '0']
- [ettus_rfnoc_streamer_radio_0, '0', ettus_rfnoc_streamer_ddc_0, '0']
- [ettus_rfnoc_streamer_vector_iir_0, '0', blocks_complex_to_real_0, '0']
- [iir_filter_xxx_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [virtual_source_0, '0', ettus_rfnoc_split_stream_0, '0']

metadata:
  file_format: 1
