options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_fir_network_host
    output_language: python
  states: {}

blocks:
- name: filter_1
  id: variable
  parameters:
    value: '[158,526,33,-445,-256,553,573,-542,-1012,349,1536,123,-2097,-1012,2633,2608,-3077,-5946,3370,20513,29295,20513,3370,-5946,-3077,2608,2633,-1012,-2097,123,1536,349,-1012,-542,573,553,-256,-445,33,526,158]'
  states: {}
- name: filter_2
  id: variable
  parameters:
    value: '[23,447,405,279,-94,-548,-792,-572,137,1023,1533,1165,-168,-1941,-3121,-2608,188,4923,10307,14569,16189,14569,10307,4923,188,-2608,-3121,-1941,-168,1165,1533,1023,137,-572,-792,-548,-94,279,405,447,23]'
  states: {}
- name: filter_coeff
  id: variable_qtgui_chooser
  parameters:
    label0: Filter 1
    label1: Filter 2
    num_opts: '2'
    option1: filter_2
    type: raw
    value: filter_1
  states: {}
- name: ip_addr
  id: variable
  parameters:
    value: '"192.168.10.2"'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: RX Freq
    orient: Qt.Horizontal
    start: 70e6
    step: 10e6
    stop: 6e9
    value: 2440e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_udp_source_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '1234'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-180'
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_rx_freq
    port: '8080'
    variable: rx_freq
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_rx_gain
    port: '8080'
    variable: rx_gain
  states: {}
- name: xmlrpc_client_0_3
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_noise_amp
    port: '8080'
    variable: noise_amp
  states: {}
- name: xmlrpc_client_0_4
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_filter_coeff
    port: '8080'
    variable: filter_coeff
  states: {}

connections:
- [blocks_udp_source_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
