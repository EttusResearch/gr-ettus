options:
  parameters:
    author: Brian Padalino
    description: Example of using the RFNoC SigGen Block
    generate_options: qt_gui
    id: rfnoc_siggen
    output_language: python
    title: RFNoC SigGen Example
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: (2, 0, 1, 1)
    label: amp
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=e3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=x300"'
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=n3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=x4xx"'
  states: {state: disabled}
- name: enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: (0,0,1,1)
    label: enable
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: device_type
    dev_args: ''
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: fs
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0,1,1)
    label: tone_freq
    outputmsgname: value
    showports: 'False'
    start: '-fs/2'
    step: '1'
    stop: fs/2
    value: fs/4
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: ettus_rfnoc_rx_streamer_0
  id: ettus_rfnoc_rx_streamer
  parameters:
    args: ''
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: '1'
  states: {}
- name: ettus_rfnoc_siggen_0
  id: ettus_rfnoc_siggen
  parameters:
    block_args: ''
    device_select: '-1'
    enable0: enable
    instance_index: '-1'
    num_chans: '1'
    sample_rate0: fs
    signal_amplitude0: amp
    signal_frequency0: tone_freq
    signal_type0: SINE_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: '1024'
    gui_hint: (3,0,1,1)
    label1: SigGen
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (4,0,1,1)
    label1: Re
    label2: Im
    size: '1024'
    srate: fs
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.ettus_rfnoc_siggen_0.set_enable(False, 0);
    comment: |-
      Automatically disables SigGen output
      when ending flowgraph
    section: main_after_stop
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [ettus_rfnoc_rx_streamer_0, '0', blocks_throttle_0, '0']
- [ettus_rfnoc_siggen_0, '0', ettus_rfnoc_rx_streamer_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
