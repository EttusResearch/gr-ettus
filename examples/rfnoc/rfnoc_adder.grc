options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_add_sub
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.4'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: z2 = x + ix
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: z = x + iy
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: numpy.array([0, 1., 2., 3.])  / 4
  states: {state: disabled}
- name: ettus_rfnoc_streamer_adder_0
  id: ettus_rfnoc_streamer_adder
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_addsub
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      1a) Re(z) = x
      1b) Im(z) = y
      2a) Re(z) + Re(z2) = x + x
      2b) Im(z) + Im(z2) = y + x
      3a) Re(z) - Re(z2) = x - x
      3b) Im(z) - Im(z2) = y - x
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_real_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_real_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', ettus_rfnoc_streamer_adder_0, '1']
- [blocks_throttle_0, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_0, '0', ettus_rfnoc_streamer_adder_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [ettus_rfnoc_streamer_adder_0, '0', qtgui_time_sink_x_0, '1']
- [ettus_rfnoc_streamer_adder_0, '1', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
