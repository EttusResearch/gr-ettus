options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: rfnoc_fft_network_usrp
    output_language: python
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.984375'
  states: {}
- name: blackman_coeff
  id: variable
  parameters:
    value: '[int(round(32767 * x)) for x in fft.window_blackman_harris(num_points)]'
  states: {}
- name: ip_addr
  id: variable
  parameters:
    value: '"192.168.10.100"'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: num_points
  id: variable
  parameters:
    value: '512'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 2450e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: wave_amp
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: wave_freq
  id: variable
  parameters:
    value: samp_rate/1000
  states: {}
- name: window_coeff
  id: variable
  parameters:
    value: blackman_coeff
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: wave_amp
    freq: wave_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_points
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '100000'
    type: complex
  states: {}
- name: ettus_rfnoc_streamer_fft_0
  id: ettus_rfnoc_streamer_fft
  parameters:
    block_index: '-1'
    device_index: '-1'
    direction: '"forward"'
    fft_size: num_points
    fpga_module_name: noc_block_fft
    magnitude_out: '"MAGNITUDE"'
    scaling: '1706'
    shift: '"normal"'
  states: {}
- name: ettus_rfnoc_streamer_window_0
  id: ettus_rfnoc_streamer_window
  parameters:
    block_index: '-1'
    coeffs: window_coeff
    device_index: '-1'
    fpga_module_name: noc_block_window
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import fft
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:4000
    pass_tags: 'True'
    timeout: '10000'
    type: complex
    vlen: num_points
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_0, '0', ettus_rfnoc_streamer_window_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [ettus_rfnoc_streamer_fft_0, '0', zeromq_push_sink_0, '0']
- [ettus_rfnoc_streamer_window_0, '0', ettus_rfnoc_streamer_fft_0, '0']

metadata:
  file_format: 1
