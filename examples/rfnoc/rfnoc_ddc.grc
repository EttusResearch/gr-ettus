options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_ddc
    output_language: python
  states: {}

blocks:
- name: decim_rate
  id: variable_qtgui_entry
  parameters:
    label: DDC Output Rate
    type: real
    value: 1e6
  states: {}
- name: master_clock_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: RX Frequency
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 6e9
    value: 2.45e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: |-
      This block allows to consume the
      output of the DDC block twice.
    enabled: 'True'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: ettus_rfnoc_streamer_ddc_0
  id: ettus_rfnoc_streamer_ddc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_ddc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: '1'
    input_rate: samp_rate
    num_chans: '1'
    output_rate: decim_rate
  states: {}
- name: ettus_rfnoc_streamer_dma_fifo_0
  id: ettus_rfnoc_streamer_dma_fifo
  parameters:
    base_addr_0: '0'
    base_addr_1: '33554432'
    block_index: '-1'
    depth_0: '33554432'
    depth_1: '33554432'
    device_index: '-1'
    fpga_module_name: noc_block_axi_dma_fifo
    grvlen: '1'
    num_chans: '1'
    otw: sc16
    type: fc32
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {state: disabled}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: 1.982e9
    freq1: 1.982e9
    gain0: '20'
    gain1: '20'
    grvlen: '1'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: samp_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '8192'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [blocks_copy_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_copy_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', ettus_rfnoc_streamer_dma_fifo_0, '0']
- [blocks_throttle_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [ettus_rfnoc_streamer_ddc_0, '0', blocks_copy_0, '0']
- [ettus_rfnoc_streamer_dma_fifo_0, '0', ettus_rfnoc_streamer_ddc_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', ettus_rfnoc_streamer_ddc_0, '0']
- [ettus_rfnoc_streamer_radio_0, '0', ettus_rfnoc_streamer_ddc_0, '0']

metadata:
  file_format: 1
