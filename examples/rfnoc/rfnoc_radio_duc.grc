options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    generate_options: qt_gui
    id: rfnoc_radio_ddc
    output_language: python
    title: 'RFNoC: DUC -> Radio Example'
  states: {}

blocks:
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: addr=192.168.30.2
    dev_args: ''
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: Gain (dB)
    type: int
    value: '0'
  states: {}
- name: master_clock_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sampling Rate (Hz)
    type: real
    value: 1e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/16
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: ettus_rfnoc_duc_0
  id: ettus_rfnoc_duc
  parameters:
    block_args: ''
    device_select: '-1'
    freq: '0'
    input_rate: samp_rate
    instance_index: '-1'
    num_chans: '1'
  states: {}
- name: ettus_rfnoc_tx_radio_0
  id: ettus_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    block_args: ''
    device_select: '-1'
    frequency: freq
    gain: gain
    instance_index: '-1'
    num_chans: '1'
    rate: master_clock_rate
  states: {}
- name: ettus_rfnoc_tx_streamer_0
  id: ettus_rfnoc_tx_streamer
  parameters:
    adapter_id_list: '[0]'
    args: ''
    input_type: fc32
    num_chans: '1'
    otw: sc16
    use_default_adapter_id: 'False'
    vlen: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', ettus_rfnoc_tx_streamer_0, '0']
- [ettus_rfnoc_duc_0, '0', ettus_rfnoc_tx_radio_0, '0']
- [ettus_rfnoc_tx_streamer_0, '0', ettus_rfnoc_duc_0, '0']

metadata:
  file_format: 1
