options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_rxtx
    output_language: python
  states: {}

blocks:
- name: master_clock_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: RX Frequency
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 6e9
    value: 2.45e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: TX Frequency
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 6e9
    value: 2.46e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: wave_amp
  id: variable_qtgui_range
  parameters:
    label: Wave Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: wave_freq
  id: variable_qtgui_range
  parameters:
    label: Wave Frequency
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: wave_amp
    freq: wave_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: ettus_rfnoc_streamer_ddc_0
  id: ettus_rfnoc_streamer_ddc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_ddc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: '1'
    input_rate: master_clock_rate
    num_chans: '1'
    output_rate: samp_rate
  states: {}
- name: ettus_rfnoc_streamer_dma_fifo_0
  id: ettus_rfnoc_streamer_dma_fifo
  parameters:
    base_addr_0: '0'
    base_addr_1: '33554432'
    block_index: '-1'
    depth_0: '33554432'
    depth_1: '33554432'
    device_index: '-1'
    fpga_module_name: noc_block_axi_dma_fifo
    grvlen: '1'
    num_chans: '1'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_duc_0
  id: ettus_rfnoc_streamer_duc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_duc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: '1'
    input_rate: samp_rate
    output_rate: master_clock_rate
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: tx
    freq0: tx_freq
    freq1: 1.982e9
    gain0: tx_gain
    gain1: '20'
    grvlen: '1'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: master_clock_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}
- name: ettus_rfnoc_streamer_radio_1
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: rx_freq
    freq1: 1.982e9
    gain0: rx_gain
    gain1: '20'
    grvlen: '1'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: master_clock_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import log
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import ceil
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', ettus_rfnoc_streamer_dma_fifo_0, '0']
- [ettus_rfnoc_streamer_ddc_0, '0', qtgui_freq_sink_x_0, '0']
- [ettus_rfnoc_streamer_dma_fifo_0, '0', ettus_rfnoc_streamer_duc_0, '0']
- [ettus_rfnoc_streamer_duc_0, '0', ettus_rfnoc_streamer_radio_0, '0']
- [ettus_rfnoc_streamer_radio_1, '0', ettus_rfnoc_streamer_ddc_0, '0']

metadata:
  file_format: 1
