options:
  parameters:
    author: Jonathon Pendlum
    generate_options: qt_gui
    id: rfnoc_radio_window
    output_language: python
    title: 'RFNoC: Window Example'
  states: {}

blocks:
- name: coeffs
  id: variable
  parameters:
    value: getattr(window, qt_window_chooser)(num_coeffs)
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=x300"'
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=e3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=n3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=x4xx"'
  states: {state: disabled}
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: device_type
    dev_args: ''
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: num_coeffs
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: qt_window_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Window Type
    label0: Blackman-Harris
    label1: Hanning
    label2: Flat Top
    label3: Triangle
    num_opts: '4'
    option0: blackmanharris
    option1: hanning
    option2: flattop
    option3: bartlett
    type: string
    value: blackmanharris
    widget: radio_buttons
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 1+1j
    type: complex
  states: {}
- name: ettus_rfnoc_rx_streamer_0
  id: ettus_rfnoc_rx_streamer
  parameters:
    args: ''
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: '1'
  states: {}
- name: ettus_rfnoc_tx_streamer_0
  id: ettus_rfnoc_tx_streamer
  parameters:
    args: ''
    input_type: fc32
    num_chans: '1'
    otw: sc16
    vlen: '1'
  states: {}
- name: ettus_rfnoc_window_0
  id: ettus_rfnoc_window
  parameters:
    block_args: ''
    coeffs_float0: coeffs
    coeffs_int0: '[int(32767*num) for num in coeffs]'
    coeffs_type0: float
    device_select: '-1'
    instance_index: '-1'
    num_chans: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 1,0,32,1
    label1: I
    label2: Q
    size: num_coeffs
    srate: '1'
    tr_delay: '2048'
    tr_level: '0.999'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '1.1'
    ymin: '-0.1'
  states: {}

connections:
- [analog_const_source_x_0, '0', ettus_rfnoc_tx_streamer_0, '0']
- [ettus_rfnoc_rx_streamer_0, '0', qtgui_time_sink_x_0, '0']
- [ettus_rfnoc_tx_streamer_0, '0', ettus_rfnoc_window_0, '0']
- [ettus_rfnoc_window_0, '0', ettus_rfnoc_rx_streamer_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
