options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_fir
    output_language: python
  states: {}

blocks:
- name: filter_1
  id: variable
  parameters:
    value: '[37,140,189,25,-199,-85,270,195,-357,-370,447,638,-534,-1052,609,1755,-668,-3270,706,10360,15665,10360,706,-3270,-668,1755,609,-1052,-534,638,447,-370,-357,195,270,-85,-199,25,189,140,37]'
  states: {}
- name: filter_2
  id: variable
  parameters:
    value: '[11,50,119,189,195,78,-148,-356,-359,-49,454,799,600,-235,-1291,-1745,-815,1681,5047,7948,9093,7948,5047,1681,-815,-1745,-1291,-235,600,799,454,-49,-359,-356,-148,78,195,189,119,50,11]'
  states: {}
- name: filter_3
  id: variable
  parameters:
    value: '[32767,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0]'
  states: {}
- name: filter_coeff
  id: variable_qtgui_chooser
  parameters:
    label0: Filter 1
    label1: Filter 2
    label2: Impulse
    num_opts: '3'
    option1: filter_2
    option2: filter_3
    type: raw
    value: filter_1
  states: {}
- name: master_clock_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: RX Freq
    orient: Qt.Horizontal
    start: 40e6
    step: 100e6
    stop: 6e9
    value: 920e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: wave_amp
  id: variable_qtgui_range
  parameters:
    label: Wave Amplitude
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: wave_freq
  id: variable_qtgui_range
  parameters:
    label: Wave Freq
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/250
    stop: samp_rate/2
    value: samp_rate/10
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: wave_amp
    freq: wave_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: ettus_rfnoc_split_stream_0
  id: ettus_rfnoc_split_stream
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_split_stream
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_ddc_0
  id: ettus_rfnoc_streamer_ddc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_ddc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: '1'
    input_rate: master_clock_rate
    num_chans: '1'
    output_rate: samp_rate
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_fir_0
  id: ettus_rfnoc_streamer_fir
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_fir_filter
    taps: filter_coeff
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: rx_freq
    freq1: 1.982e9
    gain0: rx_gain
    gain1: '20'
    grvlen: '1'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: samp_rate
    rx_bandwidth0: ''
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}
- name: note_0
  id: note
  parameters:
    note: Select input
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_copy_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_copy_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [ettus_rfnoc_split_stream_0, '0', qtgui_time_sink_x_0, '0']
- [ettus_rfnoc_split_stream_0, '1', ettus_rfnoc_streamer_fifo_0, '0']
- [ettus_rfnoc_streamer_ddc_0, '0', ettus_rfnoc_split_stream_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', ettus_rfnoc_streamer_fir_0, '0']
- [ettus_rfnoc_streamer_fir_0, '0', blocks_copy_0, '0']
- [ettus_rfnoc_streamer_radio_0, '0', ettus_rfnoc_streamer_ddc_0, '0']

metadata:
  file_format: 1
