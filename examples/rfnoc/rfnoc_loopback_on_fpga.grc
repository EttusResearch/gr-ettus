<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_loopback_on_fpga</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>stream_args</key><value>issue_stream_cmd=1,disc</value></param>
<param><key>freq</key><value>1.982e9</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>ant</key><value>"TX/RX"</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_1</value></param>
<param><key>radio_index</key><value>1</value></param>
<param><key>direction</key><value>tx</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>stream_args</key><value>disc</value></param>
<param><key>freq</key><value>1.982e9</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>ant</key><value>"TX/RX"</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
</block>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_radio_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_radio_0</sink_block_id><source_key>strobe</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_radio_1</sink_block_id><source_key>strobe</source_key><sink_key>command</sink_key></connection>
</flow_graph>
