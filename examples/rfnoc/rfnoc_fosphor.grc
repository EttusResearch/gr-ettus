options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_fosphor
    output_language: python
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,7,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '16'
    stop: '65535'
    value: '63000'
    widget: counter
  states: {}
- name: decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,7,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1024'
    value: '4'
    widget: counter
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0,1,8
    orient: Qt.Horizontal
    start: 100e6
    step: 1e3
    stop: 6000e6
    value: 1.851e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,8
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: hw_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: hw_rate / decim
  states: {}
- name: tdecay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,7,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '16'
    stop: '65535'
    value: '256'
    widget: counter
  states: {}
- name: trise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,7,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '16'
    stop: '65535'
    value: '64'
    widget: counter
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    showports: 'True'
    type: byte
    vlen: fft_size
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    showports: 'True'
    type: byte
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fosphor_hist.dat
    type: byte
    vlen: fft_size * 66
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fosphor_wf.dat
    type: byte
    vlen: fft_size
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: Histogram Tags
    type: byte
    vlen: fft_size
  states: {state: disabled}
- name: ettus_rfnoc_fosphor_display_0
  id: ettus_rfnoc_fosphor_display
  parameters:
    center_freq: '0'
    fft_bins: fft_size
    frame_rate: '30'
    grid_enabled: 'True'
    palette: iron
    pwr_bins: '64'
    samp_rate: samp_rate
    wf_enabled: 'True'
    wf_lines: '512'
  states: {}
- name: ettus_rfnoc_streamer_ddc_0
  id: ettus_rfnoc_streamer_ddc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_ddc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: fft_size
    input_rate: hw_rate
    num_chans: '1'
    output_rate: samp_rate
  states: {}
- name: ettus_rfnoc_streamer_dma_fifo_0
  id: ettus_rfnoc_streamer_dma_fifo
  parameters:
    base_addr_0: '0'
    base_addr_1: '33554432'
    block_index: '-1'
    depth_0: '33554432'
    depth_1: '33554432'
    device_index: '-1'
    fpga_module_name: noc_block_axi_dma_fifo
    grvlen: fft_size
    num_chans: '2'
    otw: u8
    type: u8
  states: {}
- name: ettus_rfnoc_streamer_fft_0
  id: ettus_rfnoc_streamer_fft
  parameters:
    block_index: '-1'
    device_index: '-1'
    direction: '"forward"'
    fft_size: fft_size
    fpga_module_name: noc_block_fft
    magnitude_out: '"COMPLEX"'
    scaling: '1706'
    shift: '"normal"'
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: fft_size
    otw: u8
    type: u8
  states: {}
- name: ettus_rfnoc_streamer_fifo_0_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: fft_size
    otw: u8
    type: u8
  states: {}
- name: ettus_rfnoc_streamer_fosphor_0
  id: ettus_rfnoc_streamer_fosphor
  parameters:
    alpha: '65280'
    block_index: '-1'
    device_index: '-1'
    epsilon: '1'
    fft_size: fft_size
    fpga_module_name: noc_block_fosphor
    hist_decim: max(2, int(samp_rate / (15 * 64 * fft_size)))
    offset: '0'
    scale: '256'
    tdecay: '16384'
    trise: '4096'
    wf_decim: '16'
    wf_mode: '-1'
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: freq
    freq1: 1.982e9
    gain0: gain
    gain1: '20'
    grvlen: fft_size
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: hw_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}
- name: ettus_rfnoc_streamer_window_0
  id: ettus_rfnoc_streamer_window
  parameters:
    block_index: '-1'
    coeffs: '[int(round(32767 * x)) for x in fft.window_blackman_harris(fft_size)]'
    device_index: '-1'
    fpga_module_name: noc_block_window
  states: {}
- name: hist_data_vsink
  id: virtual_sink
  parameters:
    stream_id: hist_data
  states: {}
- name: hist_data_vsrc
  id: virtual_source
  parameters:
    stream_id: hist_data
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import fft
  states: {}
- name: wf_data_vsink
  id: virtual_sink
  parameters:
    stream_id: wf_data
  states: {}
- name: wf_data_vsrc
  id: virtual_source
  parameters:
    stream_id: wf_data
  states: {}

connections:
- [blocks_copy_0, '0', blocks_file_sink_0, '0']
- [blocks_copy_0, '0', blocks_tag_debug_0, '0']
- [blocks_copy_0, '0', ettus_rfnoc_fosphor_display_0, '0']
- [blocks_copy_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_copy_0_0, '0', ettus_rfnoc_fosphor_display_0, '1']
- [ettus_rfnoc_fosphor_display_0, cfg, blocks_message_debug_0, print]
- [ettus_rfnoc_fosphor_display_0, cfg, ettus_rfnoc_streamer_fosphor_0, cfg]
- [ettus_rfnoc_streamer_ddc_0, '0', ettus_rfnoc_streamer_window_0, '0']
- [ettus_rfnoc_streamer_dma_fifo_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [ettus_rfnoc_streamer_dma_fifo_0, '1', ettus_rfnoc_streamer_fifo_0_0, '0']
- [ettus_rfnoc_streamer_fft_0, '0', ettus_rfnoc_streamer_fosphor_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', hist_data_vsink, '0']
- [ettus_rfnoc_streamer_fifo_0_0, '0', wf_data_vsink, '0']
- [ettus_rfnoc_streamer_fosphor_0, '0', ettus_rfnoc_streamer_dma_fifo_0, '0']
- [ettus_rfnoc_streamer_fosphor_0, '1', ettus_rfnoc_streamer_dma_fifo_0, '1']
- [ettus_rfnoc_streamer_radio_0, '0', ettus_rfnoc_streamer_ddc_0, '0']
- [ettus_rfnoc_streamer_window_0, '0', ettus_rfnoc_streamer_fft_0, '0']
- [hist_data_vsrc, '0', blocks_copy_0, '0']
- [wf_data_vsrc, '0', blocks_copy_0_0, '0']

metadata:
  file_format: 1
