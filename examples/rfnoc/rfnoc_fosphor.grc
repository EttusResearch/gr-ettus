<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_fosphor</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>63000</value></param>
<param><key>gui_hint</key><value>2,7,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>16</value></param>
<param><key>stop</key><value>65535</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>value</key><value>4</value></param>
<param><key>gui_hint</key><value>3,7,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1024</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1.851e9</value></param>
<param><key>gui_hint</key><value>8,0,1,8</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100e6</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>6000e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>9,0,1,8</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hw_rate</value></param>
<param><key>value</key><value>200e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>hw_rate / decim</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tdecay</value></param>
<param><key>value</key><value>256</value></param>
<param><key>gui_hint</key><value>1,7,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>16</value></param>
<param><key>stop</key><value>65535</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>trise</value></param>
<param><key>value</key><value>64</value></param>
<param><key>gui_hint</key><value>0,7,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>16</value></param>
<param><key>stop</key><value>65535</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0_0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/fosphor_hist.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>fft_size * 66</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/fosphor_wf.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>Histogram Tags</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>hist_data_vsink</value></param>
<param><key>stream_id</key><value>hist_data</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>hist_data_vsrc</value></param>
<param><key>stream_id</key><value>hist_data</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import fft</value></param>
</block>
<block>
<key>uhd_rfnoc_fosphor_display</key>
<param><key>id</key><value>uhd_rfnoc_fosphor_display_0</value></param>
<param><key>center_freq</key><value>freq</value></param>
<param><key>palette</key><value>iron</value></param>
<param><key>fft_bins</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>0,0,8,7</value></param>
<param><key>grid_enabled</key><value>True</value></param>
<param><key>pwr_bins</key><value>64</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>frame_rate</key><value>15</value></param>
<param><key>wf_lines</key><value>512</value></param>
<param><key>wf_enabled</key><value>True</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_ddc</key>
<param><key>id</key><value>uhd_rfnoc_streamer_ddc_0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_ddc</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
<param><key>freq</key><value>0.0</value></param>
<param><key>fullscale</key><value>1.0</value></param>
<param><key>input_rate</key><value>hw_rate</value></param>
<param><key>num_chans</key><value>1</value></param>
<param><key>output_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_dma_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_dma_fifo_0</value></param>
<param><key>base_addr_0</key><value>0</value></param>
<param><key>base_addr_1</key><value>33554432</value></param>
<param><key>depth_0</key><value>33554432</value></param>
<param><key>depth_1</key><value>33554432</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_dma_fifo</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
<param><key>type</key><value>u8</value></param>
<param><key>num_chans</key><value>2</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fft</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fft_0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>magnitude_out</key><value>"COMPLEX"</value></param>
<param><key>scaling</key><value>1706</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>fpga_module_name</key><value>noc_block_fft</value></param>
<param><key>direction</key><value>"forward"</value></param>
<param><key>shift</key><value>"normal"</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
<param><key>type</key><value>u8</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0_0</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
<param><key>type</key><value>u8</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fosphor</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fosphor_0</value></param>
<param><key>alpha</key><value>int(alpha)</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>fpga_module_name</key><value>noc_block_fosphor</value></param>
<param><key>tdecay</key><value>int(tdecay)</value></param>
<param><key>hist_decim</key><value>max(2, int(samp_rate / (15 * 64 * fft_size)))</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>trise</key><value>int(trise)</value></param>
<param><key>scale</key><value>256</value></param>
<param><key>epsilon</key><value>int(epsilon)</value></param>
<param><key>wf_decim</key><value>256</value></param>
<param><key>wf_mode</key><value>0</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>rx_bandwidth0</key><value>56e6</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>dcenable0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>lo_export0</key><value>False</value></param>
<param><key>lo_source0</key><value>"internal"</value></param>
<param><key>rx_bandwidth1</key><value>56e6</value></param>
<param><key>ant1</key><value>"TX/RX"</value></param>
<param><key>freq1</key><value>1.982e9</value></param>
<param><key>dcenable1</key><value>True</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>lo_export1</key><value>False</value></param>
<param><key>lo_source1</key><value>"internal"</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>source</key><value>"internal"</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>1</value></param>
<param><key>rate</key><value>hw_rate</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value>spp=1024</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_window</key>
<param><key>id</key><value>uhd_rfnoc_streamer_window_0</value></param>
<param><key>coeffs</key><value>[int(round(32767 * x)) for x in fft.window_blackman_harris(fft_size)]</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_window</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>wf_data_vsink</value></param>
<param><key>stream_id</key><value>wf_data</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>wf_data_vsrc</value></param>
<param><key>stream_id</key><value>wf_data</value></param>
</block>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>uhd_rfnoc_fosphor_display_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0_0</source_block_id><sink_block_id>uhd_rfnoc_fosphor_display_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hist_data_vsrc</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_fosphor_display_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>cfg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_fosphor_display_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fosphor_0</sink_block_id><source_key>cfg</source_key><sink_key>cfg</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_ddc_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_window_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_dma_fifo_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_dma_fifo_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fft_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fosphor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0</source_block_id><sink_block_id>hist_data_vsink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0_0</source_block_id><sink_block_id>wf_data_vsink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fosphor_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_dma_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fosphor_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_dma_fifo_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_ddc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_window_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wf_data_vsrc</source_block_id><sink_block_id>blocks_copy_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
