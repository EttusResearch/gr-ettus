<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_fosphor</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>184.32e6 / 2</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300,master_clock_rate=184.32e6</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import fft</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>stream_args</key><value>spp=1024</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>ant</key><value>"TX/RX"</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.45e9</value></param>
<param><key>start</key><value>1000e6</value></param>
<param><key>stop</key><value>3000e6</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>40</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tdecay</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>65535</value></param>
<param><key>step</key><value>16</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>trise</value></param>
<param><key>value</key><value>512</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>65535</value></param>
<param><key>step</key><value>16</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/out2.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0</value></param>
<param><key>type</key><value>u8</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>block_index</key><value>0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fosphor</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fosphor_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>decim</key><value>int(samp_rate / (fft_size * 64 * 30))</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>scale</key><value>256</value></param>
<param><key>trise</key><value>int(trise)</value></param>
<param><key>tdecay</key><value>int(tdecay)</value></param>
<param><key>alpha</key><value>65280</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_window</key>
<param><key>id</key><value>uhd_rfnoc_streamer_window_0</value></param>
<param><key>coeffs</key><value>[int(round(32767 * x)) for x in fft.window_blackman_harris(fft_size)]</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fft</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fft_0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>magnitude_out</key><value>"COMPLEX"</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
</block>
<block>
<key>uhd_rfnoc_fosphor_display</key>
<param><key>id</key><value>uhd_rfnoc_fosphor_display_0</value></param>
<param><key>center_freq</key><value>freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>fft_bins</key><value>fft_size</value></param>
<param><key>pwr_bins</key><value>64</value></param>
<param><key>palette</key><value>iron</value></param>
<param><key>frame_rate</key><value>15</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<connection><source_block_id>uhd_rfnoc_streamer_window_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fft_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fosphor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fosphor_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_window_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>uhd_rfnoc_fosphor_display_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_fosphor_display_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fosphor_0</sink_block_id><source_key>cfg</source_key><sink_key>cfg</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_fosphor_display_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>cfg</source_key><sink_key>print</sink_key></connection>
</flow_graph>
