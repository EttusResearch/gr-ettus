options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_siggen
    output_language: python
  states: {}

blocks:
- name: ampl_i
  id: variable_qtgui_range
  parameters:
    label: Const I
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '1.0'
  states: {}
- name: ampl_q
  id: variable_qtgui_range
  parameters:
    label: Const Q
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '1.0'
  states: {}
- name: enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Enable
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Sine Freq
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: samp_rate/10
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '1.0'
  states: {}
- name: gain_digital
  id: variable_qtgui_range
  parameters:
    label: Gain (Digital)
    orient: Qt.Horizontal
    start: '0.0'
    step: '1'
    stop: '100.0'
    value: '1.0'
  states: {}
- name: points
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    label: Waveform
    label0: Constant
    label1: Sine Wave
    label2: Noise
    num_opts: '3'
    option1: SINE_WAVE
    option2: NOISE
    type: string
    value: SINE_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ettus_rfnoc_digital_gain_0
  id: ettus_rfnoc_digital_gain
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_digital_gain
    gain: gain_digital
    grvlen: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: points
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: points
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: points
    srate: samp_rate
    type: complex
  states: {}
- name: ettus_rfnoc_streamer_siggen_0
  id: ettus_rfnoc_streamer_siggen
  parameters:
    amplitude: complex(ampl_i , ampl_q)
    block_index: '-1'
    device_index: '-1'
    enable: enable
    fpga_module_name: noc_block_siggen
    frequency: freq
    gain: gain
    samp_rate: samp_rate
    spp: points
    waveform: waveform
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [ettus_rfnoc_digital_gain_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
