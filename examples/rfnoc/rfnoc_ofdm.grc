options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ofdm_tester
    output_language: python
  states: {}

blocks:
- name: L
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0]'
  states: {}
- name: L_fft
  id: variable
  parameters:
    value: numpy.fft.ifft(numpy.fft.fftshift(L)) * fft_len
  states: {}
- name: S
  id: variable
  parameters:
    value: numpy.sqrt(13.0/6) * numpy.array([0, 0, 0, 0, 0, 0, 0, 0, 1+1j, 0, 0, 0, -1-1j, 0, 0, 0, 1+1j, 0, 0, 0, -1-1j, 0, 0, 0, -1-1j, 0, 0, 0, 1+1j, 0, 0, 0, 0, 0, 0, 0, -1-1j, 0, 0, 0, -1-1j, 0, 0, 0, 1+1j, 0, 0, 0, 1+1j, 0, 0, 0, 1+1j, 0, 0, 0, 1+1j, 0, 0, 0, 0, 0, 0, 0])
  states: {}
- name: S_fft
  id: variable
  parameters:
    value: numpy.fft.ifft(numpy.fft.fftshift(S)) * fft_len
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Multiples of Sub-carrier spacing)
    orient: Qt.Horizontal
    start: '-3'
    step: '.01'
    stop: '3'
    value: frequency_offset
  states: {}
- name: frequency_offset
  id: variable
  parameters:
    value: '0.137'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: gain_0
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '2'
    value: gain
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: noise
  id: variable
  parameters:
    value: '0'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '5'
    value: noise
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: total_preamble
  id: variable
  parameters:
    value: numpy.concatenate((S_fft[-32:], S_fft, S_fft, L_fft[-32:], L_fft, L_fft))
  states: {}
- name: usrp_b200_gain
  id: variable
  parameters:
    value: '50'
  states: {state: disabled}
- name: usrp_b200_gain_gui
  id: variable_qtgui_range
  parameters:
    label: B200 Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '75'
    value: usrp_b200_gain
  states: {}
- name: usrp_freq
  id: variable
  parameters:
    value: 920e6
  states: {state: disabled}
- name: usrp_freq_gui
  id: variable_qtgui_range
  parameters:
    label: USRP Freq
    orient: Qt.Horizontal
    start: 500e6
    step: 1e6
    stop: 2e9
    value: usrp_freq
  states: {}
- name: usrp_x300_gain
  id: variable
  parameters:
    value: '5'
  states: {state: disabled}
- name: usrp_x300_gain_gui
  id: variable_qtgui_range
  parameters:
    label: X300 Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '32'
    value: usrp_x300_gain
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: ''
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: SNR
    type: real
    value: 10 * numpy.log10(64. / 52 / noise_voltage**2) if noise_voltage > 0 else 1000
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: 2**15-1
    lo: '-2**15'
  states: {state: disabled}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: 2**15-1
    lo: '-2**15'
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: asdadf
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jpendlum/work/fpgadev-rfnoc-radio-redo/usrp3/lib/rfnoc/noc_block_ofdm_tb/ofdm_test_vectors.dat
    type: short
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 2**20
    type: short
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2**15-1
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_0
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
    len_tag_key: length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: '84'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: '50'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: len(total_preamble)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '3'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: total_preamble
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: range(0,255,2)
  states: {state: disabled}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x12, 0x34, 0x56, 0x78, 0x9A, 0xBC, 0xDE, 0xF0, 0x11, 0x22, 0x33, 0x44, 0x55, 0x66, 0x77, 0x88, 0x99, 0xAA, 0xBB, 0xCC, 0xDD, 0xEE, 0xFF)
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: byte
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset * 1.0/fft_len
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: ()
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: int(fft_len/4)
    input_size: fft_len
    tagname: length_tag_key
  states: {}
- name: ettus_rfnoc_ofdm_demap_0
  id: ettus_rfnoc_ofdm_demap
  parameters:
    block_index: '-1'
    device_index: '-1'
    fft_size: '64'
    fpga_module_name: noc_block_ofdmdemap
    mod_order: '4'
    output_type: '1'
    scaling: 1.4142135623730951/2.0
  states: {state: disabled}
- name: ettus_rfnoc_ofdm_eq_0
  id: ettus_rfnoc_ofdm_eq
  parameters:
    block_index: '-1'
    device_index: '-1'
    fft_size: '64'
    fpga_module_name: noc_block_ofdmequ
  states: {state: disabled}
- name: ettus_rfnoc_ofdm_schmidlcox_0
  id: ettus_rfnoc_ofdm_schmidlcox
  parameters:
    block_index: '-1'
    cp_len: '16'
    delay: 160+32+64-8
    device_index: '-1'
    fft_size: '64'
    fpga_module_name: noc_block_schmidl_cox
    max_num_symbols: '5'
    threshold: '0.8'
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fft_0
  id: ettus_rfnoc_streamer_fft
  parameters:
    block_index: '-1'
    device_index: '-1'
    direction: '"forward"'
    fft_size: '64'
    fpga_module_name: noc_block_fft
    magnitude_out: '"COMPLEX"'
    scaling: '1365'
    shift: '"normal"'
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '0'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '64'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_fifo_0_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '64'
    otw: sc16
    type: fc32
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fifo_0_0_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '64'
    otw: u8
    type: u8
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fifo_0_0_1
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '64'
    otw: sc16
    type: fc32
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fifo_0_0_1_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '64'
    otw: sc16
    type: fc32
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fifo_0_0_1_0_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '64'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_fifo_0_0_2
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '64'
    otw: sc16
    type: fc32
  states: {state: disabled}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: 1.982e9
    freq1: 1.982e9
    gain0: '20'
    gain1: '20'
    grvlen: '64'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '1'
    rate: samp_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1.0/fft_len,] * fft_len'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: payload
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '.1'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '.1'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '.1'
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    alpha1: '.1'
    grid: 'True'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-30'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-30'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
    ymax: 2**15
    ymin: '-2**15'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: rx_eob
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: ''
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '2048'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_eob"'
    type: float
    ymax: '256'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_eob"'
    type: float
  states: {state: disabled}
- name: samples_0
  id: virtual_sink
  parameters:
    stream_id: samples
  states: {}
- name: samples_1
  id: virtual_source
  parameters:
    stream_id: samples
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: usrp_freq_gui
    clock_rate: '0.0'
    clock_source0: external
    dev_args: '"type=b200"'
    gain0: usrp_b200_gain_gui
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_rail_ff_0, '0', blocks_float_to_complex_0, '0']
- [analog_rail_ff_0_0, '0', blocks_float_to_complex_0, '1']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_imag_0, '0', analog_rail_ff_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_head_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_complex_to_real_0, '0', analog_rail_ff_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_const_sink_x_0_0_1, '0']
- [blocks_null_source_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '2']
- [blocks_stream_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_1, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_throttle_0, '0', samples_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_vector_source_x_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_1_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_complex_to_real_1, '0']
- [blocks_vector_to_stream_0_1, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_1_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [blocks_vector_to_stream_0_1_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_1_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_vector_to_stream_0_1_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_vector_to_stream_0_1_1, '0', blocks_multiply_const_vxx_1, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', asdadf, '0']
- [ettus_rfnoc_ofdm_demap_0, '0', ettus_rfnoc_streamer_fifo_0_0_0, '0']
- [ettus_rfnoc_ofdm_demap_0, '0', ettus_rfnoc_streamer_fifo_0_0_2, '0']
- [ettus_rfnoc_ofdm_eq_0, '0', ettus_rfnoc_ofdm_demap_0, '0']
- [ettus_rfnoc_ofdm_eq_0, '0', ettus_rfnoc_streamer_fifo_0_0, '0']
- [ettus_rfnoc_ofdm_schmidlcox_0, '0', ettus_rfnoc_streamer_fft_0, '0']
- [ettus_rfnoc_ofdm_schmidlcox_0, '0', ettus_rfnoc_streamer_fifo_0_0_1_0, '0']
- [ettus_rfnoc_streamer_fft_0, '0', ettus_rfnoc_ofdm_eq_0, '0']
- [ettus_rfnoc_streamer_fft_0, '0', ettus_rfnoc_streamer_fifo_0_0_1, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', ettus_rfnoc_ofdm_schmidlcox_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', ettus_rfnoc_streamer_fifo_0_0_1_0_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0, '0', blocks_vector_to_stream_0_1, '0']
- [ettus_rfnoc_streamer_fifo_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0_1, '0', blocks_vector_to_stream_0_1_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0_1_0, '0', blocks_vector_to_stream_0_1_0_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0_1_0_0, '0', blocks_vector_to_stream_0_1_0_0_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0_2, '0', blocks_vector_to_stream_0_1_1, '0']
- [ettus_rfnoc_streamer_radio_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0_0, '0']
- [payload, '0', blocks_tagged_stream_mux_0, '1']
- [samples_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [samples_1, '0', blocks_stream_to_vector_1, '0']

metadata:
  file_format: 1
