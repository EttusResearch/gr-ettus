options:
  parameters:
    author: Jonathon Pendlum
    generate_options: qt_gui
    id: rfnoc_radio_fir_filter
    output_language: python
    title: 'RFNoC: FIR Filer Example'
  states: {}

blocks:
- name: device_type
  id: variable
  parameters:
    value: '"type=x300"'
  states: {}
- name: device_type_0
  id: variable
  parameters:
    value: '"type=x4xx"'
  states: {state: disabled}
- name: device_type_1
  id: variable
  parameters:
    value: '"type=n3xx"'
  states: {state: disabled}
- name: device_type_2
  id: variable
  parameters:
    value: '"type=e3xx"'
  states: {state: disabled}
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: device_type
    dev_args: ''
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: highpass_coeffs
  id: variable
  parameters:
    value: pm_remez(num_coeffs-1,[0.0,0.45,0.55,1.0],[0.001,0.001,1.0,1.0],[1,1])
  states: {}
- name: impulse_coeffs
  id: variable
  parameters:
    value: '[1.0] + (num_coeffs-1)*[0.0]'
  states: {}
- name: lowpass_coeffs
  id: variable
  parameters:
    value: pm_remez(num_coeffs-1,[0.0,0.45,0.55,1.0],[1,1,0.001,0.001],[1,1])
  states: {}
- name: num_coeffs
  id: variable
  parameters:
    value: '41'
  states: {}
- name: qt_filter_chooser
  id: variable_qtgui_chooser
  parameters:
    label: Filter
    label0: Lowpass
    label1: Highpass
    label2: Passthru
    num_opts: '3'
    option0: lowpass_coeffs
    option1: highpass_coeffs
    option2: impulse_coeffs
    type: raw
    value: lowpass_coeffs
    widget: radio_buttons
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.9'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: ettus_rfnoc_fir_filter_0
  id: ettus_rfnoc_fir_filter
  parameters:
    block_args: ''
    coeffs_float0: qt_filter_chooser
    coeffs_int0: '[int(32767*coeff) for coeff in qt_filter_chooser]'
    coeffs_type0: float
    device_select: '-1'
    instance_index: '-1'
    num_chans: '1'
  states: {}
- name: ettus_rfnoc_rx_streamer_0
  id: ettus_rfnoc_rx_streamer
  parameters:
    args: ''
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: '1'
  states: {}
- name: ettus_rfnoc_tx_streamer_0
  id: ettus_rfnoc_tx_streamer
  parameters:
    args: ''
    input_type: fc32
    num_chans: '1'
    otw: sc16
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.filter import pm_remez
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', ettus_rfnoc_tx_streamer_0, '0']
- [ettus_rfnoc_fir_filter_0, '0', ettus_rfnoc_rx_streamer_0, '0']
- [ettus_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']
- [ettus_rfnoc_tx_streamer_0, '0', ettus_rfnoc_fir_filter_0, '0']

metadata:
  file_format: 1
