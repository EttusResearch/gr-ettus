<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_fir_tx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_1</value></param>
<param><key>value</key><value>[158,526,33,-445,-256,553,573,-542,-1012,349,1536,123,-2097,-1012,2633,2608,-3077,-5946,3370,20513,29295,20513,3370,-5946,-3077,2608,2633,-1012,-2097,123,1536,349,-1012,-542,573,553,-256,-445,33,526,158]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_2</value></param>
<param><key>value</key><value>[23,447,405,279,-94,-548,-792,-572,137,1023,1533,1165,-168,-1941,-3121,-2608,188,4923,10307,14569,16189,14569,10307,4923,188,-2608,-3121,-1941,-168,1165,1533,1023,137,-572,-792,-548,-94,279,405,447,23]</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>filter_coeff</value></param>
<param><key>value</key><value>filter_1</value></param>
<param><key>label0</key><value>Filter 1</value></param>
<param><key>label1</key><value>Filter 2</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>filter_1</value></param>
<param><key>option1</key><value>filter_2</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>2240e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>40e6</value></param>
<param><key>step</key><value>10e6</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>31</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_noise_amp</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>0.9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_tone</value></param>
<param><key>value</key><value>samp_rate/16</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>step</key><value>samp_rate/100</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_wave_amp</value></param>
<param><key>value</key><value>0.8</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.9</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value></value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>tx_noise_amp</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>tx_wave_amp</value></param>
<param><key>freq</key><value>tx_tone</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_duc</key>
<param><key>id</key><value>uhd_rfnoc_streamer_duc_0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_duc</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>freq</key><value>0.0</value></param>
<param><key>fullscale</key><value>1.0</value></param>
<param><key>input_rate</key><value>samp_rate</value></param>
<param><key>output_rate</key><value>200e6</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fir</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fir_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_fir_filter</value></param>
<param><key>taps</key><value>filter_coeff</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>rx_bandwidth0</key><value>56e6</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>freq0</key><value>tx_freq</value></param>
<param><key>dcenable0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>lo_export0</key><value>False</value></param>
<param><key>lo_source0</key><value>"internal"</value></param>
<param><key>rx_bandwidth1</key><value>56e6</value></param>
<param><key>ant1</key><value>"TX/RX"</value></param>
<param><key>freq1</key><value>1.982e9</value></param>
<param><key>dcenable1</key><value>True</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>lo_export1</key><value>False</value></param>
<param><key>lo_source1</key><value>"internal"</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>source</key><value>"internal"</value></param>
<param><key>direction</key><value>tx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>1</value></param>
<param><key>rate</key><value>200e6</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value></value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fir_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_duc_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_radio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fir_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_duc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
