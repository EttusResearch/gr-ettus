options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_fir_tx
    output_language: python
  states: {}

blocks:
- name: filter_1
  id: variable
  parameters:
    value: '[158,526,33,-445,-256,553,573,-542,-1012,349,1536,123,-2097,-1012,2633,2608,-3077,-5946,3370,20513,29295,20513,3370,-5946,-3077,2608,2633,-1012,-2097,123,1536,349,-1012,-542,573,553,-256,-445,33,526,158]'
  states: {}
- name: filter_2
  id: variable
  parameters:
    value: '[23,447,405,279,-94,-548,-792,-572,137,1023,1533,1165,-168,-1941,-3121,-2608,188,4923,10307,14569,16189,14569,10307,4923,188,-2608,-3121,-1941,-168,1165,1533,1023,137,-572,-792,-548,-94,279,405,447,23]'
  states: {}
- name: filter_coeff
  id: variable_qtgui_chooser
  parameters:
    label0: Filter 1
    label1: Filter 2
    num_opts: '2'
    option1: filter_2
    type: raw
    value: filter_1
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 40e6
    step: 10e6
    stop: 6e9
    value: 2240e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '31'
    value: '5'
  states: {}
- name: tx_noise_amp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '0.9'
    value: '0'
  states: {}
- name: tx_tone
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: samp_rate/16
  states: {}
- name: tx_wave_amp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '0.9'
    value: '0.8'
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: tx_noise_amp
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: tx_wave_amp
    freq: tx_tone
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: ettus_rfnoc_streamer_duc_0
  id: ettus_rfnoc_streamer_duc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_duc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: '1'
    input_rate: samp_rate
    output_rate: 200e6
  states: {}
- name: ettus_rfnoc_streamer_fir_0
  id: ettus_rfnoc_streamer_fir
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_fir_filter
    taps: filter_coeff
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: tx
    freq0: tx_freq
    freq1: 1.982e9
    gain0: tx_gain
    gain1: '20'
    grvlen: '1'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: 200e6
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', ettus_rfnoc_streamer_fir_0, '0']
- [ettus_rfnoc_streamer_duc_0, '0', ettus_rfnoc_streamer_radio_0, '0']
- [ettus_rfnoc_streamer_fir_0, '0', ettus_rfnoc_streamer_duc_0, '0']

metadata:
  file_format: 1
