options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: rfnoc_fosphor_network_usrp
    output_language: python
  states: {}

blocks:
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: ettus_rfnoc_streamer_fft_0
  id: ettus_rfnoc_streamer_fft
  parameters:
    block_index: '-1'
    device_index: '-1'
    direction: '"forward"'
    fft_size: fft_size
    fpga_module_name: noc_block_fft
    magnitude_out: '"COMPLEX"'
    scaling: '1706'
    shift: '"normal"'
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: fft_size
    otw: u8
    type: u8
  states: {}
- name: ettus_rfnoc_streamer_fifo_0_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: fft_size
    otw: u8
    type: u8
  states: {}
- name: ettus_rfnoc_streamer_fosphor_0
  id: ettus_rfnoc_streamer_fosphor
  parameters:
    alpha: '65280'
    block_index: '-1'
    device_index: '-1'
    epsilon: '1'
    fft_size: fft_size
    fpga_module_name: noc_block_fosphor
    hist_decim: max(2, int(samp_rate / (15 * 64 * fft_size)))
    offset: '0'
    scale: '256'
    tdecay: '16384'
    trise: '4096'
    wf_decim: '16'
    wf_mode: '-1'
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: freq
    freq1: 1.982e9
    gain0: gain
    gain1: '20'
    grvlen: fft_size
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: samp_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}
- name: ettus_rfnoc_streamer_window_0
  id: ettus_rfnoc_streamer_window
  parameters:
    block_index: '-1'
    coeffs: '[int(round(32767 * x)) for x in fft.window_blackman_harris(fft_size)]'
    device_index: '-1'
    fpga_module_name: noc_block_window
  states: {}
- name: fft_size
  id: parameter
  parameters:
    type: intx
    value: '512'
  states: {}
- name: fpga_path
  id: parameter
  parameters:
    value: '"/home/root/e300.bit"'
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 2.45e9
  states: {}
- name: gain
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: host_ip_addr
  id: parameter
  parameters:
    value: '"192.168.10.100"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import fft
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 56e6
  states: {}
- name: tdecay
  id: parameter
  parameters:
    type: intx
    value: '4096'
  states: {}
- name: trise
  id: parameter
  parameters:
    type: intx
    value: '1024'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://" + host_ip_addr + ":4001"'
    timeout: '100'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:4000
    pass_tags: 'True'
    timeout: '10000'
    type: byte
    vlen: fft_size
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:4001
    pass_tags: 'True'
    timeout: '10000'
    type: byte
    vlen: fft_size
  states: {}

connections:
- [ettus_rfnoc_streamer_fft_0, '0', ettus_rfnoc_streamer_fosphor_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', zeromq_push_sink_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0, '0', zeromq_push_sink_0_0, '0']
- [ettus_rfnoc_streamer_fosphor_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [ettus_rfnoc_streamer_fosphor_0, '1', ettus_rfnoc_streamer_fifo_0_0, '0']
- [ettus_rfnoc_streamer_radio_0, '0', ettus_rfnoc_streamer_window_0, '0']
- [ettus_rfnoc_streamer_window_0, '0', ettus_rfnoc_streamer_fft_0, '0']
- [zeromq_pull_msg_source_0, out, ettus_rfnoc_streamer_fosphor_0, cfg]

metadata:
  file_format: 1
