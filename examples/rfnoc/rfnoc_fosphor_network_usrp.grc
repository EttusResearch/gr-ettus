<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_fosphor_network_usrp</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=e3x0</value></param>
<param><key>dev_args</key><value>"master_clock_rate=%d,fpga=%s" % (samp_rate,fpga_path)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fpga_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/home/root/e300.bit"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.45e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host_ip_addr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"192.168.10.100"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import fft</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>56e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tdecay</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>trise</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fft</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fft_0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>magnitude_out</key><value>"COMPLEX"</value></param>
<param><key>scaling</key><value>1706</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>fpga_module_name</key><value>noc_block_fft</value></param>
<param><key>direction</key><value>"forward"</value></param>
<param><key>shift</key><value>"normal"</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
<param><key>type</key><value>u8</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0_0</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
<param><key>type</key><value>u8</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fosphor</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fosphor_0</value></param>
<param><key>alpha</key><value>63000</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>fpga_module_name</key><value>noc_block_fosphor</value></param>
<param><key>tdecay</key><value>int(tdecay)</value></param>
<param><key>hist_decim</key><value>max(2, int(samp_rate / (15 * 64 * fft_size)))</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>trise</key><value>int(trise)</value></param>
<param><key>scale</key><value>256</value></param>
<param><key>epsilon</key><value>0</value></param>
<param><key>wf_decim</key><value>64</value></param>
<param><key>wf_mode</key><value>0</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>rx_bandwidth0</key><value>56e6</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>dcenable0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>lo_export0</key><value>False</value></param>
<param><key>lo_source0</key><value>"internal"</value></param>
<param><key>rx_bandwidth1</key><value>56e6</value></param>
<param><key>ant1</key><value>"TX/RX"</value></param>
<param><key>freq1</key><value>1.982e9</value></param>
<param><key>dcenable1</key><value>True</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>lo_export1</key><value>False</value></param>
<param><key>lo_source1</key><value>"internal"</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>fft_size</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>source</key><value>"internal"</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value>"spp=%d" % fft_size</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_window</key>
<param><key>id</key><value>uhd_rfnoc_streamer_window_0</value></param>
<param><key>coeffs</key><value>[int(round(32767 * x)) for x in fft.window_blackman_harris(fft_size)]</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_window</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>8080</value></param>
</block>
<block>
<key>zeromq_pull_msg_source</key>
<param><key>id</key><value>zeromq_pull_msg_source_0</value></param>
<param><key>address</key><value>"tcp://" + host_ip_addr + ":4001"</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0</value></param>
<param><key>address</key><value>tcp://*:4000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>10000</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0_0</value></param>
<param><key>address</key><value>tcp://*:4001</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>10000</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<connection><source_block_id>uhd_rfnoc_streamer_fft_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fosphor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0</source_block_id><sink_block_id>zeromq_push_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0_0</source_block_id><sink_block_id>zeromq_push_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fosphor_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fosphor_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_window_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_window_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fosphor_0</sink_block_id><source_key>out</source_key><sink_key>cfg</sink_key></connection>
</flow_graph>
