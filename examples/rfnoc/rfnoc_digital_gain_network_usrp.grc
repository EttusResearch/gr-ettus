options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: rfnoc_digital_gain_network_usrp
    output_language: python
  states: {}

blocks:
- name: ampl_i
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ampl_q
  id: variable
  parameters:
    value: '1'
  states: {}
- name: enable
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: freq
  id: variable
  parameters:
    value: samp_rate/10
  states: {}
- name: gain_digital
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: gain_siggen
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: ip_addr
  id: variable
  parameters:
    value: '"192.168.10.100"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: waveform
  id: variable
  parameters:
    value: '"SINE_WAVE"'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: ip_addr
    port: '1234'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: ettus_rfnoc_digital_gain_0
  id: ettus_rfnoc_digital_gain
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_digital_gain
    gain: gain_digital
    grvlen: '1'
  states: {}
- name: ettus_rfnoc_streamer_siggen_0
  id: ettus_rfnoc_streamer_siggen
  parameters:
    amplitude: complex(ampl_i , ampl_q)
    block_index: '-1'
    device_index: '-1'
    enable: enable
    fpga_module_name: noc_block_siggen
    frequency: freq
    gain: gain_siggen
    samp_rate: samp_rate
    spp: '364'
    waveform: waveform
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}

connections:
- [ettus_rfnoc_digital_gain_0, '0', blocks_udp_sink_0, '0']
- [ettus_rfnoc_streamer_siggen_0, '0', ettus_rfnoc_digital_gain_0, '0']

metadata:
  file_format: 1
