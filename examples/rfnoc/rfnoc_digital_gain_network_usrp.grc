<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_digital_gain_network_usrp</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ampl_i</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ampl_q</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>device3</value></param>
<param><key>dev_addr</key><value>type=e3x0</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>enable</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>samp_rate/10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_digital</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_siggen</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_addr</value></param>
<param><key>value</key><value>"192.168.10.100"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>waveform</value></param>
<param><key>value</key><value>"SINE_WAVE"</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>ip_addr</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>uhd_rfnoc_digital_gain</key>
<param><key>id</key><value>uhd_rfnoc_digital_gain_0</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_digital_gain</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>gain</key><value>gain_digital</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_siggen</key>
<param><key>id</key><value>uhd_rfnoc_streamer_siggen_0</value></param>
<param><key>amplitude</key><value>complex(ampl_i , ampl_q)</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>enable</key><value>enable</value></param>
<param><key>fpga_module_name</key><value>noc_block_siggen</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>gain</key><value>gain_siggen</value></param>
<param><key>spp</key><value>364</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>waveform</key><value>waveform</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>8080</value></param>
</block>
<connection><source_block_id>uhd_rfnoc_digital_gain_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_siggen_0</source_block_id><sink_block_id>uhd_rfnoc_digital_gain_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
