options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_fir_fft
    output_language: python
  states: {}

blocks:
- name: filter_1
  id: variable
  parameters:
    value: '[158,526,33,-445,-256,553,573,-542,-1012,349,1536,123,-2097,-1012,2633,2608,-3077,-5946,3370,20513,29295,20513,3370,-5946,-3077,2608,2633,-1012,-2097,123,1536,349,-1012,-542,573,553,-256,-445,33,526,158]'
  states: {}
- name: filter_2
  id: variable
  parameters:
    value: '[23,447,405,279,-94,-548,-792,-572,137,1023,1533,1165,-168,-1941,-3121,-2608,188,4923,10307,14569,16189,14569,10307,4923,188,-2608,-3121,-1941,-168,1165,1533,1023,137,-572,-792,-548,-94,279,405,447,23]'
  states: {}
- name: filter_coeff
  id: variable_qtgui_chooser
  parameters:
    label0: Filter 1
    label1: Filter 2
    num_opts: '2'
    option1: filter_2
    type: raw
    value: filter_1
  states: {}
- name: master_clock_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: num_points
  id: variable
  parameters:
    value: '256'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: RX Freq
    orient: Qt.Horizontal
    start: 40e6
    step: 10e6
    stop: 6e9
    value: 2440e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: wave_amp
  id: variable_qtgui_range
  parameters:
    label: Wave Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.9'
  states: {}
- name: wave_freq
  id: variable_qtgui_range
  parameters:
    label: Wave Freq
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/128
    stop: samp_rate/2
    value: samp_rate/8
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: wave_amp
    freq: wave_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '256'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '256'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: ettus_rfnoc_streamer_ddc_0
  id: ettus_rfnoc_streamer_ddc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_ddc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: num_points
    input_rate: master_clock_rate
    num_chans: '1'
    output_rate: samp_rate
  states: {}
- name: ettus_rfnoc_streamer_fft_0
  id: ettus_rfnoc_streamer_fft
  parameters:
    block_index: '-1'
    device_index: '-1'
    direction: '"forward"'
    fft_size: num_points
    fpga_module_name: noc_block_fft
    magnitude_out: '"COMPLEX"'
    scaling: '1706'
    shift: '"normal"'
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {state: disabled}
- name: ettus_rfnoc_streamer_fir_0
  id: ettus_rfnoc_streamer_fir
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_fir_filter
    taps: filter_coeff
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: rx_freq
    freq1: 1.982e9
    gain0: rx_gain
    gain1: '20'
    grvlen: num_points
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: master_clock_rate
    rx_bandwidth0: ''
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}
- name: note_0
  id: note
  parameters:
    note: Run by using F6
  states: {}
- name: note_1
  id: note
  parameters:
    note: Select input
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    showports: 'True'
    vlen: num_points
    x_start: '-samp_rate/2'
    x_step: samp_rate/num_points
    x_units: '"dB"'
    y_units: '"MHz"'
    ymax: '0'
    ymin: '-100'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_throttle_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [ettus_rfnoc_streamer_ddc_0, '0', ettus_rfnoc_streamer_fir_0, '0']
- [ettus_rfnoc_streamer_fft_0, '0', blocks_complex_to_mag_squared_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', ettus_rfnoc_streamer_fir_0, '0']
- [ettus_rfnoc_streamer_fir_0, '0', ettus_rfnoc_streamer_fft_0, '0']
- [ettus_rfnoc_streamer_radio_0, '0', ettus_rfnoc_streamer_ddc_0, '0']

metadata:
  file_format: 1
