options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_debug
    output_language: python
  states: {}

blocks:
- name: enable_null_sink
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Enable Null Sink
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: enable_null_src
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Enable Null Source
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: master_clock_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: 200e3
    step: '100000'
    stop: 200e6
    value: 1e6
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: TX Frequency
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 6e9
    value: 2.46e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: wave_amp
  id: variable_qtgui_range
  parameters:
    label: Wave Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: wave_freq
  id: variable_qtgui_range
  parameters:
    label: Wave Frequency
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: wave_amp
    freq: wave_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '10'
    type: float
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: ettus_rfnoc_streamer_debug_0
  id: ettus_rfnoc_streamer_debug
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_debug
    null_sink: enable_null_sink
    null_src: enable_null_src
    spp: '64'
  states: {}
- name: ettus_rfnoc_streamer_dma_fifo_0
  id: ettus_rfnoc_streamer_dma_fifo
  parameters:
    base_addr_0: '0'
    base_addr_1: '33554432'
    block_index: '-1'
    depth_0: '33554432'
    depth_1: '33554432'
    device_index: '-1'
    fpga_module_name: noc_block_axi_dma_fifo
    grvlen: '1'
    num_chans: '1'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_duc_0
  id: ettus_rfnoc_streamer_duc
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_duc
    freq: '0.0'
    fullscale: '1.0'
    grvlen: '1'
    input_rate: samp_rate
    output_rate: master_clock_rate
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: item32
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: tx
    freq0: tx_freq
    freq1: 1.982e9
    gain0: tx_gain
    gain1: '20'
    grvlen: '1'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: master_clock_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import log
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import ceil
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Downsteam Full (Xfer)"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Upsteam Empty (Xfer)"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Xfer Cycles"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Packet Size"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Upsteam Empty (Idle)"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0_2
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Idle Cycles"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0_2_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Throttled Cycles"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Idle Cycles"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_1_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Cycle Count"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_2
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Downsteam Full (Idle)"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Downsteam Full (Xfer)"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Downsteam Full (Idle)"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Upsteam Empty (Xfer)"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Upsteam Empty (Idle)"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Idle Cycles"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_1_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Throttled Cycles"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Idle Cycles"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_2_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Cycle Count"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_3
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Xfer Cycles"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_4
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    name: '"Packet Size"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10000'
    ymin: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', ettus_rfnoc_streamer_dma_fifo_0, '0']
- [blocks_deinterleave_0, '0', qtgui_number_sink_0_0_0_0_2_0, '0']
- [blocks_deinterleave_0, '0', qtgui_time_sink_x_0_0_1_1_0, '0']
- [blocks_deinterleave_0, '1', qtgui_number_sink_0_0_0, '0']
- [blocks_deinterleave_0, '1', qtgui_time_sink_x_0_0_0, '0']
- [blocks_deinterleave_0, '2', qtgui_number_sink_0_0_0_0, '0']
- [blocks_deinterleave_0, '2', qtgui_time_sink_x_0_0_1, '0']
- [blocks_deinterleave_0, '3', qtgui_number_sink_0_0_0_0_2, '0']
- [blocks_deinterleave_0, '3', qtgui_time_sink_x_0_0_1_1, '0']
- [blocks_deinterleave_0, '4', qtgui_number_sink_0_0_0_2, '0']
- [blocks_deinterleave_0, '4', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_deinterleave_0, '5', qtgui_number_sink_0_0_0_0_1, '0']
- [blocks_deinterleave_0, '5', qtgui_time_sink_x_0_0_1_0, '0']
- [blocks_deinterleave_0, '6', qtgui_number_sink_0_0_0_1_0, '0']
- [blocks_deinterleave_0, '6', qtgui_time_sink_x_0_0_2_0, '0']
- [blocks_deinterleave_0, '7', qtgui_number_sink_0_0_0_1, '0']
- [blocks_deinterleave_0, '7', qtgui_time_sink_x_0_0_2, '0']
- [blocks_deinterleave_0, '8', qtgui_number_sink_0_0_0_0_0, '0']
- [blocks_deinterleave_0, '8', qtgui_time_sink_x_0_0_3, '0']
- [blocks_deinterleave_0, '9', qtgui_number_sink_0_0_0_0_0_0, '0']
- [blocks_deinterleave_0, '9', qtgui_time_sink_x_0_0_4, '0']
- [blocks_int_to_float_0_0, '0', blocks_deinterleave_0, '0']
- [ettus_rfnoc_streamer_debug_0, '0', ettus_rfnoc_streamer_duc_0, '0']
- [ettus_rfnoc_streamer_debug_0, '1', ettus_rfnoc_streamer_fifo_0, '0']
- [ettus_rfnoc_streamer_dma_fifo_0, '0', ettus_rfnoc_streamer_debug_0, '0']
- [ettus_rfnoc_streamer_duc_0, '0', ettus_rfnoc_streamer_radio_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', blocks_int_to_float_0_0, '0']

metadata:
  file_format: 1
