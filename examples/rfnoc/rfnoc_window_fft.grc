options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_window_fft
    output_language: python
  states: {}

blocks:
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: num_points
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: variable_ettus_device3_0
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: ''
  states: {}
- name: wave_amp
  id: variable_qtgui_range
  parameters:
    label: Wave Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.9'
  states: {}
- name: wave_freq
  id: variable_qtgui_range
  parameters:
    label: Wave Freq
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/128
    stop: samp_rate/2
    value: samp_rate/8
  states: {}
- name: window_coeff
  id: variable_qtgui_entry
  parameters:
    label: Window Coeff
    type: raw
    value: '[0,2,7,16,29,45,65,89,116,148,183,222,266,314,366,422,483,549,620,695,776,862,953,1050,1153,1261,1376,1496,1623,1757,1897,2043,2197,2358,2526,2701,2883,3074,3272,3477,3691,3912,4142,4380,4626,4880,5142,5413,5692,5979,6275,6579,6891,7211,7540,7876,8220,8572,8932,9299,9674,10056,10445,10840,11242,11651,12065,12485,12911,13342,13778,14218,14662,15111,15563,16017,16475,16935,17397,17860,18324,18789,19253,19718,20182,20644,21104,21563,22018,22470,22919,23363,23802,24237,24665,25087,25503,25911,26312,26704,27088,27462,27828,28183,28527,28861,29183,29494,29793,30079,30352,30613,30859,31092,31311,31515,31705,31880,32039,32183,32312,32425,32522,32603,32668,32717,32750,32766,32766,32750,32717,32668,32603,32522,32425,32312,32183,32039,31880,31705,31515,31311,31092,30859,30613,30352,30079,29793,29494,29183,28861,28527,28183,27828,27462,27088,26704,26312,25911,25503,25087,24665,24237,23802,23363,22919,22470,22018,21563,21104,20644,20182,19718,19253,18789,18324,17860,17397,16935,16475,16017,15563,15111,14662,14218,13778,13342,12911,12485,12065,11651,11242,10840,10445,10056,9674,9299,8932,8572,8220,7876,7540,7211,6891,6579,6275,5979,5692,5413,5142,4880,4626,4380,4142,3912,3691,3477,3272,3074,2883,2701,2526,2358,2197,2043,1897,1757,1623,1496,1376,1261,1153,1050,953,862,776,695,620,549,483,422,366,314,266,222,183,148,116,89,65,45,29,16,7,2,0]'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: wave_amp
    freq: wave_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_points
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: num_points
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_points
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ettus_rfnoc_streamer_fft_0
  id: ettus_rfnoc_streamer_fft
  parameters:
    block_index: '-1'
    device_index: '-1'
    direction: '"forward"'
    fft_size: num_points
    fpga_module_name: noc_block_fft
    magnitude_out: '"COMPLEX"'
    scaling: '1706'
    shift: '"normal"'
  states: {}
- name: ettus_rfnoc_streamer_fifo_0_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: num_points
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_window_0
  id: ettus_rfnoc_streamer_window
  parameters:
    block_index: '-1'
    coeffs: window_coeff
    device_index: '-1'
    fpga_module_name: noc_block_window
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    showports: 'True'
    vlen: num_points
    x_start: '-samp_rate/2'
    x_step: samp_rate/num_points
    x_units: '"dB"'
    y_units: '"MHz"'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', ettus_rfnoc_streamer_window_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [ettus_rfnoc_streamer_fft_0, '0', ettus_rfnoc_streamer_fifo_0_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [ettus_rfnoc_streamer_window_0, '0', ettus_rfnoc_streamer_fft_0, '0']

metadata:
  file_format: 1
