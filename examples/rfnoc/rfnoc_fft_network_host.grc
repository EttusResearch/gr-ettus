<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_fft_network_host</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>blackman_coeff</value></param>
<param><key>value</key><value>[int(round(32767 * x)) for x in fft.window_blackman_harris(num_points)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>boxcar_coeff</value></param>
<param><key>value</key><value>num_points*[32767]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hamming_coeff</value></param>
<param><key>value</key><value>[int(round(32767 * x)) for x in fft.window_hamming(num_points)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_addr</value></param>
<param><key>value</key><value>"192.168.10.2"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>label</key><value>Noise Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_points</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>50e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wave_amp</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>label</key><value>Wave Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wave_freq</value></param>
<param><key>value</key><value>samp_rate/10</value></param>
<param><key>label</key><value>Wave Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>step</key><value>samp_rate/100</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>window_coeff</value></param>
<param><key>value</key><value>blackman_coeff</value></param>
<param><key>label0</key><value>Blackman-Harris</value></param>
<param><key>label1</key><value>Hamming</value></param>
<param><key>label2</key><value>Rectangular</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>blackman_coeff</value></param>
<param><key>option1</key><value>hamming_coeff</value></param>
<param><key>option2</key><value>boxcar_coeff</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
<param><key>vlen</key><value>num_points</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>num_points</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import fft</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>num_points</value></param>
<param><key>x_start</key><value>-samp_rate/2</value></param>
<param><key>x_step</key><value>samp_rate/num_points</value></param>
<param><key>x_units</key><value>"dB"</value></param>
<param><key>y_units</key><value>"MHz"</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_0_1</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_wave_freq</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>wave_freq</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_0_2</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_wave_amp</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>wave_amp</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_0_3</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_noise_amp</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>noise_amp</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_0_3_0</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_window_coeff</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>window_coeff</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>"tcp://" + ip_addr + ":4000"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>10000</value></param>
<param><key>vlen</key><value>num_points</value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
