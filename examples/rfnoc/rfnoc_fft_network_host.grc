options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_fft_network_host
    output_language: python
  states: {}

blocks:
- name: blackman_coeff
  id: variable
  parameters:
    value: '[int(round(32767 * x)) for x in fft.window_blackman_harris(num_points)]'
  states: {}
- name: boxcar_coeff
  id: variable
  parameters:
    value: num_points*[32767]
  states: {}
- name: hamming_coeff
  id: variable
  parameters:
    value: '[int(round(32767 * x)) for x in fft.window_hamming(num_points)]'
  states: {}
- name: ip_addr
  id: variable
  parameters:
    value: '"192.168.10.2"'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: num_points
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: wave_amp
  id: variable_qtgui_range
  parameters:
    label: Wave Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.9'
  states: {}
- name: wave_freq
  id: variable_qtgui_range
  parameters:
    label: Wave Freq
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: samp_rate/10
  states: {}
- name: window_coeff
  id: variable_qtgui_chooser
  parameters:
    label0: Blackman-Harris
    label1: Hamming
    label2: Rectangular
    num_opts: '3'
    option1: hamming_coeff
    option2: boxcar_coeff
    type: raw
    value: blackman_coeff
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: num_points
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: num_points
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import fft
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    showports: 'True'
    vlen: num_points
    x_start: '-samp_rate/2'
    x_step: samp_rate/num_points
    x_units: '"dB"'
    y_units: '"MHz"'
  states: {}
- name: xmlrpc_client_0_1
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_wave_freq
    port: '8080'
    variable: wave_freq
  states: {}
- name: xmlrpc_client_0_2
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_wave_amp
    port: '8080'
    variable: wave_amp
  states: {}
- name: xmlrpc_client_0_3
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_noise_amp
    port: '8080'
    variable: noise_amp
  states: {}
- name: xmlrpc_client_0_3_0
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_window_coeff
    port: '8080'
    variable: window_coeff
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: '"tcp://" + ip_addr + ":4000"'
    pass_tags: 'True'
    timeout: '10000'
    type: complex
    vlen: num_points
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [zeromq_pull_source_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
