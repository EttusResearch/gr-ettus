options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: rfnoc_fir_network_usrp
    output_language: python
  states: {}

blocks:
- name: filter_coeff
  id: variable
  parameters:
    value: '[158,526,33,-445,-256,553,573,-542,-1012,349,1536,123,-2097,-1012,2633,2608,-3077,-5946,3370,20513,29295,20513,3370,-5946,-3077,2608,2633,-1012,-2097,123,1536,349,-1012,-542,573,553,-256,-445,33,526,158]'
  states: {}
- name: ip_addr
  id: variable
  parameters:
    value: '"192.168.10.100"'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 2440e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: variable_ettus_device3_0
  id: variable_ettus_device3
  parameters:
    dev_addr: type=e3x0
    dev_args: ''
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: ip_addr
    port: '1234'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_fir_0
  id: ettus_rfnoc_streamer_fir
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_fir_filter
    taps: filter_coeff
  states: {}
- name: ettus_rfnoc_streamer_radio_0
  id: ettus_rfnoc_streamer_radio
  parameters:
    ant0: ''
    ant1: ''
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: rx
    freq0: rx_freq
    freq1: 1.982e9
    gain0: rx_gain
    gain1: '20'
    grvlen: '1'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: samp_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {state: disabled}
- name: ettus_rfnoc_streamer_siggen_0
  id: ettus_rfnoc_streamer_siggen
  parameters:
    amplitude: complex(1.0 , 1.0)
    block_index: '-1'
    device_index: '-1'
    enable: '0'
    fpga_module_name: noc_block_siggen
    frequency: 0.1e6
    gain: '1.0'
    samp_rate: samp_rate
    spp: '364'
    waveform: '"NOISE"'
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', ettus_rfnoc_streamer_fir_0, '0']
- [ettus_rfnoc_streamer_fir_0, '0', blocks_udp_sink_0, '0']
- [ettus_rfnoc_streamer_radio_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [ettus_rfnoc_streamer_siggen_0, '0', ettus_rfnoc_streamer_fifo_0, '0']

metadata:
  file_format: 1
