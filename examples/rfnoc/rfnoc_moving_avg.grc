options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: avg_length
  id: variable_qtgui_entry
  parameters:
    label: Length
    type: int
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: variable_ettus_device3
  id: variable_ettus_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: 500e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_length
    max_iter: '4000'
    scale: 1.0/avg_length
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0.5, ) + (0, ) * (avg_length-1)
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.01'
    seed: '0'
    taps: '1'
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_moving_avg_0
  id: ettus_rfnoc_streamer_moving_avg
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_moving_avg
    length: avg_length
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: '"RFNoC"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: '"GNURadio"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [channels_channel_model_0, '0', blocks_moving_average_xx_0, '0']
- [channels_channel_model_0, '0', ettus_rfnoc_streamer_moving_avg_0, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', qtgui_time_sink_x_0, '0']
- [ettus_rfnoc_streamer_moving_avg_0, '0', ettus_rfnoc_streamer_fifo_0, '0']

metadata:
  file_format: 1
