options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_fosphor_network_host
    output_language: python
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 0, 1, 5
    orient: Qt.Horizontal
    start: 50e6
    step: 10e6
    stop: 6e9
    value: 2440e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 5, 1, 5
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '32'
  states: {}
- name: ip_addr
  id: variable
  parameters:
    comment: USRP IP Address
    value: '"192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 56e6
  states: {}
- name: tdecay
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,11,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '16'
    stop: '4096'
    value: '4096'
  states: {}
- name: trise
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 10, 1, 1
    orient: Qt.Horizontal
    start: '0'
    step: '16'
    stop: '4096'
    value: '1024'
  states: {}
- name: ettus_rfnoc_fosphor_display_0
  id: ettus_rfnoc_fosphor_display
  parameters:
    center_freq: '0'
    fft_bins: fft_size
    frame_rate: '30'
    grid_enabled: 'True'
    palette: iron
    pwr_bins: '64'
    samp_rate: samp_rate
    wf_enabled: 'True'
    wf_lines: '512'
  states: {}
- name: xmlrpc_client_freq
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_freq
    port: '8080'
    variable: freq
  states: {}
- name: xmlrpc_client_gain
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_gain
    port: '8080'
    variable: gain
  states: {}
- name: xmlrpc_client_tdecay
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_tdecay
    port: '8080'
    variable: tdecay
  states: {}
- name: xmlrpc_client_trise
  id: xmlrpc_client
  parameters:
    addr: ip_addr
    callback: set_trise
    port: '8080'
    variable: trise
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: '"tcp://" + ip_addr + ":4000"'
    pass_tags: 'True'
    timeout: '10000'
    type: byte
    vlen: fft_size
  states: {}
- name: zeromq_pull_source_0_0
  id: zeromq_pull_source
  parameters:
    address: '"tcp://" + ip_addr + ":4001"'
    pass_tags: 'True'
    timeout: '10000'
    type: byte
    vlen: fft_size
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://*:4001
    timeout: '100'
  states: {}

connections:
- [ettus_rfnoc_fosphor_display_0, cfg, zeromq_push_msg_sink_0, in]
- [zeromq_pull_source_0, '0', ettus_rfnoc_fosphor_display_0, '0']
- [zeromq_pull_source_0_0, '0', ettus_rfnoc_fosphor_display_0, '1']

metadata:
  file_format: 1
