<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_fosphor_network_host</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2440e6</value></param>
<param><key>gui_hint</key><value>10, 0, 1, 5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50e6</value></param>
<param><key>step</key><value>10e6</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>32</value></param>
<param><key>gui_hint</key><value>10, 5, 1, 5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>76</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_addr</value></param>
<param><key>comment</key><value>USRP IP Address</value></param>
<param><key>value</key><value>"192.168.10.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>56e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tdecay</value></param>
<param><key>value</key><value>4096</value></param>
<param><key>gui_hint</key><value>10,11,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>16</value></param>
<param><key>stop</key><value>4096</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>trise</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>gui_hint</key><value>10, 10, 1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>16</value></param>
<param><key>stop</key><value>4096</value></param>
</block>
<block>
<key>uhd_rfnoc_fosphor_display</key>
<param><key>id</key><value>uhd_rfnoc_fosphor_display_0</value></param>
<param><key>center_freq</key><value>freq</value></param>
<param><key>palette</key><value>iron</value></param>
<param><key>fft_bins</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>0, 0, 10, 12</value></param>
<param><key>grid_enabled</key><value>True</value></param>
<param><key>pwr_bins</key><value>64</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>frame_rate</key><value>15</value></param>
<param><key>wf_lines</key><value>512</value></param>
<param><key>wf_enabled</key><value>True</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_freq</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_freq</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>freq</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_gain</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_gain</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>gain</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_tdecay</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_tdecay</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>tdecay</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_trise</value></param>
<param><key>addr</key><value>ip_addr</value></param>
<param><key>callback</key><value>set_trise</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>trise</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>"tcp://" + ip_addr + ":4000"</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>10000</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0_0</value></param>
<param><key>address</key><value>"tcp://" + ip_addr + ":4001"</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>10000</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>zeromq_push_msg_sink</key>
<param><key>id</key><value>zeromq_push_msg_sink_0</value></param>
<param><key>address</key><value>tcp://*:4001</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>uhd_rfnoc_fosphor_display_0</source_block_id><sink_block_id>zeromq_push_msg_sink_0</sink_block_id><source_key>cfg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>uhd_rfnoc_fosphor_display_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0_0</source_block_id><sink_block_id>uhd_rfnoc_fosphor_display_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
